# Keil uVision project DS18B20.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC12C5A60S2 STC12C5A16S2 Series
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2
  output: STCAD +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 DS18B20.c stc12c.C LCD12864.c main.c sys.c DS12887.c timer.c
